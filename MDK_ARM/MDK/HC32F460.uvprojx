# Keil uVision project HC32F460.uvprojx, settings and files
target debug (6240000::V6.24::.\ARMCLANG6_22)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F460.1.0.12
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Panel +hex
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bin --output=build/@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: HC32F460,USE_DDL_DRIVER,__DEBUG,__CORE_DEBUG,USE_FREERTOS
  c include: ..\..\config;..\..\user\inc;..\..\platform\cmsis\Include;..\..\platform\cmsis\Device\HDSC\hc32f4xx\Include;..\..\platform\core;..\..\platform\ll_drivers\hc32_ll_driver\inc;..\..\platform\ll_drivers\bsp\ev_hc32f460_lqfp100_v2;..\..\Arduino;..\..\Arduino\avr;..\..\Arduino\variants\hc32f460xx;..\..\libraries\FreeRTOS;..\..\libraries\FreeRTOS\include;..\..\libraries\FreeRTOS\portable\GCC\ARM_CM4F;..\..\libraries\Parser;..\..\libraries\lwmem\src\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\config\linker\HC32F460xE.sct
  link misc: --keep=*Handler
  group user
    ../../user/: main.cpp
  group platform/cmsis
    ../../platform/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
    ../../platform/cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f460.s
  group platform/core
    ../../platform/newlibc/: newlib.c
    ../../platform/core/: delay.cpp heap_init.c
  group platform/ll_drivers
    ../../platform/ll_drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_clk.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_gpio.c hc32_ll_i2c.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_pwc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_tmr0.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_fcm.c hc32_ll_wdt.c hc32_ll_trng.c
  group Arduino
    ../../Arduino/: itoa.c HardwareSerial.cpp Print.cpp Stream.cpp wiring_digital.cpp WMath.cpp WString.cpp yield.c wiring_analog.cpp
    ../../Arduino/avr/: dtostrf.c
  group Arduino/drivers/adc
    ../../Arduino/drivers/adc/: adc.cpp adc_config.cpp
  group Arduino/drivers/gpio
    ../../Arduino/drivers/gpio/: addon_gpio.c
  group Arduino/drivers/irqn
    ../../Arduino/drivers/irqn/: irqn.cpp
  group Arduino/drivers/panic
    ../../Arduino/drivers/panic/: ddl_assert.c panic.cpp
  group Arduino/drivers/sysclock
    ../../Arduino/drivers/sysclock/: sysclock.cpp
  group Arduino/drivers/timera
    ../../Arduino/drivers/timera/: timera_config.cpp
  group Arduino/drivers/usart
    ../../Arduino/drivers/usart/: usart_config.cpp usart_sync.cpp
  group Arduino/libraries/Timer0
    ../../Arduino/libaries/Timer0/src/: Timer0.cpp timer0_config.cpp
  group Arduino/libraries/IWatchDog
    ../../Arduino/libaries/IWatchdog/: IWatchdog.cpp
  group Arduino/variants
    ../../Arduino/variants/hc32f460xx/: variant.cpp
  group Libaries/Parser
    ../../libraries/Parser/: Parse_Custom.cpp Parse_NMEA.cpp Parse_RTCM.cpp Parse_UBLOX.cpp Parse_Unicore_Binary.cpp Parse_Unicore_Hash.cpp SparkFun_Extensible_Message_Parser.cpp
  group Libaries/FreeRTOS
    ../../libraries/FreeRTOS/: croutine.c list.c queue.c stream_buffer.c tasks.c timers.c event_groups.c FreeRTOSConfig.h
    ../../libraries/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
    ../../libraries/FreeRTOS/portable/MemMang/: heap_4.c
  group Libaries/lw_mem
    ../../libraries/lwmem/src/lwmem/: lwmem.c lwmem.cpp
