# Keil uVision project EmptyMain.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.12
  cpu: IROM1(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: EmptyMain
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x03000C00 size 0x3C0
  memory RVCT9: RAM 0x1FFF8000 size 0x2F000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  group Source Group 1
    ../: main.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
